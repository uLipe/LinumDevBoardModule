## boards/witte/linum_dev/board.yml
```yaml
board:
  name: linum_dev
  full_name: Linum Board
  vendor: witte
  socs:
    - name: stm32h753xx
```
